## ased-assignments/config.in
```kconfig
config BR2_PACKAGE_AESD_ASSIGNMENTS
    bool aesd-assignments
    depends on BR2_PACKAGE_HAS_SSH
    help
      Enable support for AESD assignments
```
